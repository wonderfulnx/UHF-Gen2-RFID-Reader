options:
  parameters:
    author: Xin Na
    generate_options: qt_gui
    id: ad9361_rfidreader
    output_language: python
    title: AD9361 TX RX RFIDReader
  states: {}

blocks:
- name: SSBnXTsamp
  id: variable_qtgui_range
  parameters:
    gui_hint: (6, 1)
    label: SSBnXTsamp
    start: '0'
    step: '0.01'
    stop: '0.25'
    value: '0.02'
  states: {}
- name: SSKp
  id: variable_qtgui_range
  parameters:
    gui_hint: (5, 1)
    label: SSKp
    start: '0.5'
    step: '0.1'
    stop: '5.0'
    value: '2.7'
  states: {}
- name: SSdoo
  id: variable_qtgui_range
  parameters:
    comment: |-
      The three range parameters are for symbol synchronizer inside
      reader receiver processing:
       - SSdoo: Damping factor of the loop filter.
       - SSKp:  Timing error detector gain.
       - SSBnXTsamp: Loop bandwidth (Bn) normalized by the sample rate (Tsamp).
      Tuning of these three parameter is critical to signal demodulation.
       - First, damping factor is usually set to 1 and will generally work. 
          Usually there is no need to tune it.
       - Second, SSBnXTsamp parameter should usually be within (0, 0.1),
          it should always be greater than 0. This parameter defines the
          expected drifting value, and should be larger in high BLF scenarios.
          A good empirical value would be 0.02 for low BLF and 0.06 for 640kHz BLF. 
       - Third, SSKp should also be positive, with a default value of 2.7. This
          value defines the gain of timing error in loop filter. A smaller SSKp
          means a higher gain of timing error. A good empirical value would
          be 2.7 for low BLF and 1.6~1.8 for 640kHz BLF, we also suggest
          tuning this parameter yourself if the default does not work well.
    gui_hint: (4, 1)
    label: SSdoo
    start: '0.5'
    step: '0.1'
    stop: '2.0'
    value: '1.0'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: record_btn
  id: variable_qtgui_toggle_switch
  parameters:
    comment: GUI Record Switch
    gui_hint: (7, 1)
    initPressed: 'False'
    label: Toggle On to Record Data
    position: '3'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: rx0dma_selector
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (1, 1)
    label: Rx0 DMA Selection
    labels: '["Rx to RFID sys", "Rx on to RFID sys", "Rx Symbol Sync Output", "Decode Result"]'
    num_opts: '0'
    options: '[1, 2, 3, 4]'
    type: int
    value: '4'
  states: {}
- name: rx1dma_selector
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (2, 1)
    label: Rx1 DMA Selection
    labels: '["Rx to RFID sys", "Rx on to RFID sys", "Rx Symbol Sync Output", "Decode Result"]'
    num_opts: '0'
    options: '[1, 2, 3, 4]'
    type: int
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Set this value to 8 * BLF of RFID BLF.
      This is the actual sample rate of our model,
      althrough it runs at 61.44MHz clock.
    value: 0.32e6
  states: {}
- name: uri_ctx
  id: variable
  parameters:
    comment: The IP address for zed+ad9361 device
    value: '"ip:192.168.20.2"'
  states: {}
- name: ad9361_reader_config
  id: epy_module
  parameters:
    comment: |-
      The ad9361 SDR and reader configuration
      SDR Includes sampling rate, RF bandwidth, gain, etc.
      Reader includes symbol sync calculation function.
      sampling rate set to 61.44Msps.
    source_code: |
      # this module will be imported in the into your flowgraph

      config_list = [
      "out_altvoltage0_RX_LO_frequency=915000000",
      "out_altvoltage1_TX_LO_frequency=915000000",
      "in_voltage_sampling_frequency=61440000",
      "out_voltage_sampling_frequency=61440000",
      "in_voltage_rf_bandwidth=32000000",
      "out_voltage_rf_bandwidth=32000000",
      "in_voltage0_gain_control_mode=manual",
      "in_voltage1_gain_control_mode=manual",
      "in_voltage0_hardwaregain=5",
      "in_voltage1_hardwaregain=0",
      "out_voltage0_hardwaregain=0",
      "out_voltage1_hardwaregain=-80",
      "in_voltage_quadrature_tracking_en=0",
      "in_voltage_bb_dc_offset_tracking_en=0",
      "in_voltage_rf_dc_offset_tracking_en=0"
      ]

      def SSPiLoopConstants(SSBnXTsamp, SSdoo, SSKp):
          d = dict()
          SSth = SSBnXTsamp / (SSdoo + 0.25 / SSdoo)
          SSd  = 1 + 2 * SSdoo * SSth + SSth ** 2
          SSK0 = -1
          d['K1'] = 4 * SSdoo * (SSth/SSd) * (1 / (SSKp*SSK0))
          d['K2'] = 4 *   (SSth**2 / SSd)   * (1 / (SSKp*SSK0))
          return d
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: |-
      The sampling rate of tx can be set very
      low without affecting system performance,
      but it can't be deleted.
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: 0.32e6
    type: short
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    comment: |-
      Use this in Windows:
      "./signals/rxdma" if record_btn == 1 else "NUL"
      Use this in Linux
      "./signals/rxdma" if record_btn == 1 else "/dev/null"
    file: '"./signals/rxdma" if record_btn == 1 else "NUL"'
    type: short
    vlen: '4'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32768'
    vlen: '4'
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '4'
    type: short
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '4'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\nclass overflow_detect(gr.sync_block):\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Overflow Detector',   # will show up in GRC\n            in_sig=[np.int32],\n            out_sig=None,\n        )\n        self.logger = gr.logger(self.alias())\n        # self.message_port_register_out(pmt.intern('overflow_msg'))\n        \n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        # self.example_param = example_param\n\n    def work(self, input_items, output_items):\n        # print(input_items)\n        for val in input_items[0]:\n            if (val & 4):\n                self.logger.warn(\"Overflow!\")\n                # self.message_port_pub(pmt.intern('overflow_msg'), pmt.intern('Overflow!'))\n                break\n        return len(input_items[0])\n        \n"
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Make Dict Msg for IIO Attr ',
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self.handle_msg)
              self.message_port_register_out(pmt.intern('out'))

          def handle_msg(self, msg):
              key_pmt = pmt.car(msg)
              val_pmt = pmt.cdr(msg)
              d_msg = pmt.make_dict()
              d_msg = pmt.dict_add(d_msg, key_pmt, val_pmt)
              self.message_port_pub(pmt.intern('out'), d_msg)
    example_param: '1.0'
  states: {}
- name: iio_attr_sink_0
  id: iio_attr_sink
  parameters:
    attr_type: '1'
    comment: Custom IP control
    device: axi-rfidreader
    uri: uri_ctx
  states: {}
- name: iio_attr_sink_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '4'
    device: '"cf-ad9361-lpc"'
    uri: uri_ctx
  states: {}
- name: iio_attr_source_0
  id: iio_attr_source
  parameters:
    address: int("0x80000088",0)
    attr_type: '3'
    comment: Monitor Overflow
    device: cf-ad9361-lpc
    samples_per_update: '16'
    type: '3'
    update_interval_ms: '100'
    uri: uri_ctx
  states: {}
- name: iio_attr_updater_0
  id: iio_attr_updater
  parameters:
    attr: loopback_delay
    comment: |-
      Loopback delay
      in 61.44MHz clock
    interval: '0'
    value: '104'
  states: {}
- name: iio_attr_updater_0_0
  id: iio_attr_updater
  parameters:
    attr: ssk1
    comment: Symbol Sync PI Loop parameter K1
    interval: '0'
    value: str(round(ad9361_reader_config.SSPiLoopConstants(SSBnXTsamp, SSdoo, SSKp)['K1'] * 32768))
  states: {}
- name: iio_attr_updater_0_0_0_1
  id: iio_attr_updater
  parameters:
    attr: tx_mag
    comment: |-
      Tx magnitude
      The model accepts signed fixed point type, sfix16_En15.
      So here the input is a int16.
    interval: '0'
    value: str(round(-0.8*32768))
  states: {}
- name: iio_attr_updater_0_0_0_1_0
  id: iio_attr_updater
  parameters:
    attr: q
    comment: Q value in EPC protocol
    interval: '0'
    value: '0'
  states: {}
- name: iio_attr_updater_0_0_1
  id: iio_attr_updater
  parameters:
    attr: tx_sel
    comment: |-
      1 for Loopback PIE
      2 for RFID signal
    interval: '0'
    value: '2'
  states: {}
- name: iio_attr_updater_0_0_1_0
  id: iio_attr_updater
  parameters:
    attr: rx_sel
    comment: |-
      1 for Capture High rate signal
      2 for Receive Low rate signal
    interval: '0'
    value: '2'
  states: {}
- name: iio_attr_updater_0_0_2
  id: iio_attr_updater
  parameters:
    attr: rx0dma_sel
    interval: '0'
    value: str(rx0dma_selector)
  states: {}
- name: iio_attr_updater_0_0_3
  id: iio_attr_updater
  parameters:
    attr: rx1dma_sel
    comment: |-
      rx_sel == 1
        1 for Tx Signal
        2 for Rx channel 0
        3 for Rx channel 1
      rx_sel == 2
        1 for Rx to RFID sys
        2 for Rx on signal input to RFID sys
        3 for Rx symbol sync output
        4 for Rx Decode Result
    interval: '0'
    value: str(rx1dma_selector)
  states: {}
- name: iio_attr_updater_0_0_4
  id: iio_attr_updater
  parameters:
    attr: str(int('0x80000088', 16))
    comment: Use to set initial overflow bit
    interval: '0'
    value: str(int('0x6', 16))
  states: {}
- name: iio_attr_updater_0_1
  id: iio_attr_updater
  parameters:
    attr: dual_target
    comment: Dual target in EPC protocol
    interval: '0'
    value: '1'
  states: {}
- name: iio_attr_updater_0_2
  id: iio_attr_updater
  parameters:
    attr: ssk2
    comment: Symbol Sync PI Loop parameter K2
    interval: '0'
    value: str(round(ad9361_reader_config.SSPiLoopConstants(SSBnXTsamp, SSdoo, SSKp)['K2'] * 32768))
  states: {}
- name: iio_device_sink_0
  id: iio_device_sink
  parameters:
    buffer_size: '65536'
    channels: '["voltage0", "voltage1"]'
    comment: |-
      Tx chain for ad9361
      Data is not actually used but don't delete this.
    cyclic: 'False'
    device: cf-ad9361-dds-core-lpc
    device_phy: ad9361-phy
    interpolation: '1'
    params: '[]'
    uri: uri_ctx
  states: {}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: '65536'
    channels: '["voltage0", "voltage1", "voltage2", "voltage3"]'
    comment: Rx chain for ad9361
    decimation: '1'
    device: cf-ad9361-lpc
    device_phy: ad9361-phy
    params: ad9361_reader_config.config_list
    uri: uri_ctx
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: (8, 1)
    name: '"ad9361 channel 0"'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: (9, 1)
    name: '"ad9361 channel 1"'
    type: complex
  states: {}
- name: reset_ip_msg_push_button
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: (3, 1)
    label: Reset RFID Reader IP (Restart after click)
    msgName: reset_ip
    type: string
    value: '1'
  states: {}

connections:
- [analog_sig_source_x_0, '0', iio_device_sink_0, '0']
- [analog_sig_source_x_0, '0', iio_device_sink_0, '1']
- [blocks_float_to_complex_0, '0', qtgui_sink_x_0, '0']
- [blocks_float_to_complex_0_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_short_to_float_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_file_sink_1_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_short_to_float_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_float_to_complex_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_float_to_complex_0, '1']
- [blocks_vector_to_streams_0, '2', blocks_float_to_complex_0_0, '0']
- [blocks_vector_to_streams_0, '3', blocks_float_to_complex_0_0, '1']
- [epy_block_1, out, iio_attr_sink_0, attr]
- [iio_attr_source_0, '0', epy_block_0, '0']
- [iio_attr_updater_0, out, iio_attr_sink_0, attr]
- [iio_attr_updater_0_0, out, iio_attr_sink_0, attr]
- [iio_attr_updater_0_0_0_1, out, iio_attr_sink_0, attr]
- [iio_attr_updater_0_0_0_1_0, out, iio_attr_sink_0, attr]
- [iio_attr_updater_0_0_1, out, iio_attr_sink_0, attr]
- [iio_attr_updater_0_0_1_0, out, iio_attr_sink_0, attr]
- [iio_attr_updater_0_0_2, out, iio_attr_sink_0, attr]
- [iio_attr_updater_0_0_3, out, iio_attr_sink_0, attr]
- [iio_attr_updater_0_0_4, out, iio_attr_sink_0_0, attr]
- [iio_attr_updater_0_1, out, iio_attr_sink_0, attr]
- [iio_attr_updater_0_2, out, iio_attr_sink_0, attr]
- [iio_device_source_0, '0', blocks_streams_to_vector_0, '0']
- [iio_device_source_0, '1', blocks_streams_to_vector_0, '1']
- [iio_device_source_0, '2', blocks_streams_to_vector_0, '2']
- [iio_device_source_0, '3', blocks_streams_to_vector_0, '3']
- [reset_ip_msg_push_button, pressed, epy_block_1, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
